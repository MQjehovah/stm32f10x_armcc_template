# Keil uVision project project.uvprojx, settings and files
target project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10x_md,USE_STDPERIPH_DRIVER
  c include: ..\..\src\Driver\inc;..\..\src\FWLib\inc;..\..\src\Startup\inc;..\..\src\User\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../src/Startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group Driver
    ../../src/Driver/: GPIO.c USART.c
  group FWLib
    ../../src/FWLib/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../../src/User/: delay.c main.c stm32f10x_it.c
